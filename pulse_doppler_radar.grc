options:
  parameters:
    author: Steven
    generate_options: qt_gui
    id: Pulse_doppler
    output_language: python
    title: Pulse_doppler
  states: {}

blocks:
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '240'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: save.dat
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1, 0, 0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: TX_Waveform
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: TX_Waveform_Re
    label2: TX_Waveform_Im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: RX_Waveform_Re
    label2: RX_Waveform_Im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: RX_Waveform_Magnitude
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: RX_Re
    size: 1024*8
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_repeat_0, '0', iio_pluto_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
